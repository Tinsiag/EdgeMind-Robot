# Repository Tinsiag/EdgeMind-Robot (continued)

## KiCad design pcb/power/kicad/ProPrj_power_2026-10-02.kicad_pcb (continued)

Parts:
C118, C119, C120: 100nF/50V; C_0805_2012Metric
J15: 急停常闭回路; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
R69, R70, R71, R72: 10k; R_0603_1608Metric
R73: 4.7k; R_0603_1608Metric
U10: 74HC08D; SOIC-14_3.9x8.7mm_P1.27mm; MPN SN74HC08DR
U12: 74HC74D; SOIC-14_3.9x8.7mm_P1.27mm; MPN SN74HC74DR
U13: MCP100-300DI/TO; TO-92_Inline; MPN MCP100-300DI/TO

Connections:
+3V3: C118.1, C119.1, C120.1, J15.1, R72.1, U10.14 (VCC), U12.2 (D), U12.4 (~S), U12.10 (~S), U12.14 (VCC), U13.2 (VDD); also elsewhere on the board
ESTOP_OK: J15.2, R69.1, U10.1; also elsewhere on the board
EXT_KILL_N: R72.2, U10.5; also elsewhere on the board
GND: C118.2, C119.2, C120.2, R69.2, R70.2, R71.2, R73.2, U10.7 (GND), U12.7 (GND), U12.11 (C), U12.12 (D), U12.13 (~R), U13.3 (VSS); also elsewhere on the board
MOTOR_ARM: R71.1, U12.3 (C); also elsewhere on the board
MOTOR_ARMED: R73.1, U12.5 (Q); also elsewhere on the board
MOTOR_PERMIT: R70.1, U10.2; also elsewhere on the board
MOTOR_POWER_OK: U10.13; also elsewhere on the board
unnamed: U10.3, U10.9
unnamed: U10.6, U10.10
unnamed: U10.8, U10.12
unnamed: U10.11, U12.1 (~R)
POR_OK: U10.4, U13.1 (~RST); also elsewhere on the board

Notes on the sheet:
急停断开、运行许可撤销、外部故障、欠压或过流均立即清除解锁。 条件恢复后还须发出解锁脉冲；逻辑板须在看门狗超时或堵转时撤销运行许可。 使用支持3.3V的74HC08与74HC74，不可换成74LS系列。
动力硬件锁存：上电关闭 / 常闭急停 / 解锁需要上升沿

Parts:
C121: 100nF/50V; C_0805_2012Metric
D4, D5, D6: BZT52C12; D_SOD-123
J16: 左回生泄放 / 外接3.3Ω; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J17: 右回生泄放 / 外接3.3Ω; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
Q2: IRF4905; TO-220-3_Vertical; MPN IRF4905
Q5: MMBT3904; SOT-23; MPN MMBT3904
Q6, Q7: IRLZ44N; TO-220-3_Vertical; MPN IRLZ44N
R74: 10k; R_0603_1608Metric
R75, R78, R82: 4.7k; R_0603_1608Metric
R76, R80: 51.1k/0.1%; R_0603_1608Metric
R77, R81: 10.0k/0.1%; R_0603_1608Metric
R79, R83: 1M; R_0603_1608Metric
TP1: 电机总开关输出; TestPoint_Pad_D2.0mm
U24: LM393BIDR; SOIC-8_3.9x4.9mm_P1.27mm; MPN LM393BIDR

Connections:
GND: C121.2, D5.2 (A), D6.2 (A), Q5.2 (E), Q6.3 (S), Q7.3 (S), R77.2, R81.2, U24.4 (V-); also elsewhere on the board
MOTOR_ARMED: R75.1; also elsewhere on the board
unnamed: D4.2 (A), Q2.1 (G), Q5.3 (C), R74.2
unnamed: D5.1 (K), Q6.1 (G), R78.2, R79.2, U24.1
unnamed: D6.1 (K), Q7.1 (G), R82.2, R83.2, U24.7
unnamed: J16.2, Q6.2 (D)
unnamed: J17.2, Q7.2 (D)
unnamed: Q5.1 (B), R75.2
unnamed: R76.2, R77.1, R79.1, U24.3 (+)
unnamed: R80.2, R81.1, R83.1, U24.5 (+)
VBAT_SYS: C121.1, D4.1 (K), Q2.3 (S), R74.1, U24.8 (V+); also elsewhere on the board
VM_L: J16.1, R76.1, R78.1; also elsewhere on the board
VM_R: J17.1, R80.1, R82.1; also elsewhere on the board
VM_SWITCHED: Q2.2 (D), TP1.1 (1_1); also elsewhere on the board
VREF_2V495: U24.2 (-), U24.6 (-); also elsewhere on the board

Notes on the sheet:
回生能量泄放 / 外接底盘散热电阻
约15.39V开始泄放；关闭阈值和最坏过冲须实测。 若电源或电池保护板不能吸收回生，外接两只3.3Ω、至少100W的底盘散热电阻。 电路由电池母线供电，本板3.3V消失时仍可工作；功率管需要散热。
动力总开关 / 急停触点只承载控制电流
