# Repository Tinsiag/EdgeMind-Robot (continued)

## KiCad design pcb/power/kicad/ProPrj_power_2026-10-02.kicad_pcb (continued)

Parts:
C1, C2, C3, C4, C5, C8, C9, C10, C12, C13: 22uF/25V; C_0805_2012Metric
C6, C14: 100nF/50V; C_0603_1608Metric
C7, C15: 220pF/C0G; C_0603_1608Metric
C11, C16, C104, C106: 1uF/25V; C_0805_2012Metric
C105, C107: 4.7uF/10V; C_0805_2012Metric
L1, L2: 4.7uH; L_Changjiang_FXL0630; MPN FXL0630-4R7-M
R1, R6: 10R; R_0603_1608Metric
R2, R11: 82.5k/0.1%; R_0603_1608Metric
R3, R12: 11.0k/0.1%; R_0603_1608Metric
R65, R67: 150k/1%; R_0603_1608Metric
R66, R68: 10k; R_0603_1608Metric
U1, U5: MP2236GJ-Z; TSOT-23-8; MPN MP2236GJ-Z
U7, U8: HUSB305-02; TSOT-23-8; MPN HUSB305-02
USB1, USB2: USB4125-GF-A / 六针供电; USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal; MPN USB4125-GF-A

Connections:
+3V3: R66.1, R68.1; also elsewhere on the board
+5V_AI: C12.1, C13.1, C15.1, L2.2, R11.1; also elsewhere on the board
+5V_AI_PROT: C106.1, U8.1 (VIN); also elsewhere on the board
+5V_FPGA: C4.1, C5.1, C7.1, L1.2, R2.1; also elsewhere on the board
+5V_FPGA_PROT: C104.1, U7.1 (VIN); also elsewhere on the board
BUCK_ENABLE: U1.6 (EN), U5.6 (EN); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C16.2, C104.2, C105.2, C106.2, C107.2, R3.2, R12.2, R65.2, R67.2, U1.1 (AGND), U1.4 (GND), U5.1 (AGND), U5.4 (GND), U7.2 (GND), U8.2 (GND), USB1.A12 (GND), USB1.B12 (GND), USB1.SH (SHIELD), USB2.A12 (GND), USB2.B12 (GND), USB2.SH (SHIELD); also elsewhere on the board
unnamed: C6.1, R1.2
unnamed: C14.1, R6.2
unnamed: R6.1, U1.5 (BST)
unnamed: C15.2, R11.2, R12.1, U1.8 (FB)
unnamed: C14.2, L2.1, U1.3 (SW)
unnamed: C16.1, U1.7 (VCC)
unnamed: R1.1, U5.5 (BST)
unnamed: C7.2, R2.2, R3.1, U5.8 (FB)
unnamed: C6.2, L1.1, U5.3 (SW)
unnamed: C11.1, U5.7 (VCC)
unnamed: U7.6 (CC1), USB1.A5 (CC1)
unnamed: U7.5 (CC2), USB1.B5 (CC2)
unnamed: R65.1, U7.3 (ISET)
unnamed: U8.6 (CC1), USB2.A5 (CC1)
unnamed: U8.5 (CC2), USB2.B5 (CC2)
unnamed: R67.1, U8.3 (ISET)
USB1_FAULT_PULSE_N: R66.2, U7.7 (STAT); also elsewhere on the board
USB1_VBUS: C105.1, U7.8 (VBUS), USB1.A9 (VBUS), USB1.B9 (VBUS)
USB2_FAULT_PULSE_N: R68.2, U8.7 (STAT); also elsewhere on the board
USB2_VBUS: C107.1, U8.8 (VBUS), USB2.A9 (VBUS), USB2.B9 (VBUS)
VLOGIC_IN: C1.1, C2.1, C3.1, C8.1, C9.1, C10.1, U1.2 (IN), U5.2 (IN); also elsewhere on the board

Notes on the sheet:
逻辑板降压输出 / 5.10V / 供电目标3A
USB2 / 六针供电口 / 固定5V
连接检测与总线电源开关由控制器完成 限流电阻150kΩ：典型限流3.6A，宣告供电能力3A 无需外部上拉电阻；仅固定5V供电
两路 5V 不并联。实际负载、板端电压、线缆压降和温升需实测；USB-C 不宣告 4A。
计算板降压输出 / 5.10V / 供电目标3A
USB1 / 六针供电口 / 固定5V

Parts:
C139, C140, C141, C142: 100nF/50V; C_0805_2012Metric
D7, D8: BZT52C12; D_SOD-123
Q8, Q10: AO4409; SOIC-8_3.9x4.9mm_P1.27mm; MPN AO4409
Q9, Q11, Q13: MMBT3904; SOT-23; MPN MMBT3904
Q12: AO3401A; SOT-23; MPN AO3401A
R104, R109: 11.5k/0.1%; R_0603_1608Metric
R105, R110, R115, R120, R123: 10.0k/0.1%; R_0603_1608Metric
R106, R111, R118, R121: 10k; R_0603_1608Metric
R107, R112, R116: 1k; R_0603_1608Metric
R108, R113, R117: 4.7k; R_0603_1608Metric
R114: 3.83k/0.1%; R_0603_1608Metric
R119: 30.9k/0.1%; R_0603_1608Metric
R122: 10.5k/0.1%; R_0603_1608Metric
U27, U28, U29, U30: LM393BIDR; SOIC-8_3.9x4.9mm_P1.27mm; MPN LM393BIDR

Connections:
3V3_ONBOARD_OK: R117.1, R118.2, U29.1
+3V3: R121.1; also elsewhere on the board
+3V3_ONBOARD: Q12.3 (D); also elsewhere on the board
+3V3_RAW: Q12.2 (S), R114.1, R116.2; also elsewhere on the board
+5V_AI: D8.1 (K), Q10.1 (S), Q10.2 (S), Q10.3 (S), R109.1, R112.1; also elsewhere on the board
+5V_AI_OK: R111.2, R113.1, U28.1
+5V_AI_PROT: Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D); also elsewhere on the board
+5V_FPGA: D7.1 (K), Q8.1 (S), Q8.2 (S), Q8.3 (S), R104.1, R107.1; also elsewhere on the board
+5V_FPGA_OK: R106.2, R108.1, U27.1
+5V_FPGA_PROT: Q8.5 (D), Q8.6 (D), Q8.7 (D), Q8.8 (D); also elsewhere on the board
BAT_WARN_N: R121.2, U29.7; also elsewhere on the board
CURRENT_REF_1V217: R122.2, R123.1, U30.3 (+), U30.5 (+)
GND: C139.2, C140.2, C141.2, C142.2, Q9.2 (E), Q11.2 (E), Q13.2 (E), R105.2, R110.2, R115.2, R120.2, R123.2, U27.4 (V-), U27.5 (+), U28.4 (V-), U28.5 (+), U29.4 (V-), U30.4 (V-); also elsewhere on the board
MOTOR_POWER_OK: U30.1, U30.7; also elsewhere on the board
unnamed: D7.2 (A), Q8.4 (G), Q9.3 (C), R107.2
unnamed: D8.2 (A), Q10.4 (G), Q11.3 (C), R112.2
unnamed: Q9.1 (B), R108.2
unnamed: Q11.1 (B), R113.2
unnamed: Q12.1 (G), Q13.3 (C), R116.1
unnamed: Q13.1 (B), R117.2
unnamed: R104.2, R105.1, U27.2 (-)
unnamed: R109.2, R110.1, U28.2 (-)
unnamed: R114.2, R115.1, U29.2 (-)
unnamed: R119.2, R120.1, U29.5 (+)
VBAT_SYS: C139.1, C140.1, C141.1, C142.1, R106.1, R111.1, R118.1, R119.1, U27.8 (V+), U28.8 (V+), U29.8 (V+), U30.8 (V+); also elsewhere on the board
VM_L_IMON: U30.2 (-); also elsewhere on the board
VM_R_IMON: U30.6 (-); also elsewhere on the board
VREF_2V495: R122.1, U27.3 (+), U27.6 (-), U28.3 (+), U28.6 (-), U29.3 (+), U29.6 (-); also elsewhere on the board

Notes on the sheet:
逻辑板供电过压关断 / 标称约5.364V
板载3.3V过压关断 / 标称约3.451V
动力过流检测 / 滤波后母线电流 / 共用锁存清除
计算板供电过压关断 / 标称约5.364V
分立过压关断方案用于控制成本；故障阶跃过冲和温升须实测。 本方案不保证所有状态下阻断反灌，接入板卡仍须核对电源选择与隔离。 母线过流阈值标称约3.04A；入口总保险板载，电池单体保护和模块限流仍须落实。
