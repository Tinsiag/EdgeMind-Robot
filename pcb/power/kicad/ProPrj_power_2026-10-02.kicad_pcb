# Repository Tinsiag/EdgeMind-Robot

File README.md:

# EdgeMind-Robot

基于 ACG720 FPGA 与 Lichee Pi 4A 的摄像头、激光雷达和差速小车项目。

本地按键选择绕障、原地一圈或视觉任务；4A 提供 NPU 检测和网页预览。
当前功能与验收边界见[项目状态](docs/project-status.md)，维护说明见[文档索引](docs/README.md)。

```powershell
& code/camera-car-control/.venv/Scripts/python.exe -B scripts/check_project.py
```

该命令只检查本地项目、链接和签核记录，不连接开发板。

图像用于展示视频识别界面，不代替当前位流的实屏验收。

## 安装与开发

使用 Python 3.12、WSL 的 Icarus/Verilator 和 Gowin 工具链。
开发环境、测试、构建及签核命令见[开发指南](docs/contributing.md)。
已有的 `code/camera-car-control/.venv/` 是开发环境，不属于历史构建缓存。

## 使用

- 小车按键、三种模式及限制：[模式操作](code/camera-car-control/a745-autonomous/docs/README-MODES-AND-TARGET-74513.md)。
- 4A 视频、NPU 和部署：[视频服务](code/camera-car-control/a745-autonomous/host/README-video.md)。
- IMU、编码器和启动故障：[排障说明](docs/troubleshooting.md)。
- 当前位流与验收依据：[STATUS.json](output/current-firmware/STATUS.json)。

启动运动由本机 S1 完成，网络不提供 ARM 或故障清除。
相机与雷达未完成实物标定，视觉自动接近保持禁用。

## 目录

| 目录 | 内容 |
| --- | --- |
| `code/camera-car-control/a745-autonomous/` | 活动 FPGA 工程、4A 服务和测试 |
| `code/ld06-radar-gui/` | 独立雷达串口诊断工具 |
| `scripts/fpga/` | 烧录、只读采集和签核工具 |
| `model/` | 当前 V5 装配、其必需的 V4 输入及器件模型 |
| `pcb/power/` | 电源/电机驱动板原始设计与元件库 |
| `doc/` | 硬件原始资料、接线和供电预算 |
| `docs/` | 项目说明、开发、状态和维护文档 |
| `output/current-firmware/` | 当前签核、Flash 审计及已记录的实物证据 |

## 参与维护

先读[维护约定](AGENTS.md)与[维护说明](docs/maintenance.md)。
历史交接入口已撤除；以当前状态和相应审计核实版本。
本轮整理的检查和删除计划见[整理记录](output/project-maintenance-20261104/RESULT.json)。

## 许可

项目未声明统一开源许可证。
第三方 RTL、器件资料和模型按各自许可与来源说明使用，原许可文件保留。

## KiCad design pcb/power/kicad/ProPrj_power_2026-10-02.kicad_pcb

File pcb/power/kicad/README.md:

# 电源板 KiCad 工程

主工程 `ProPrj_power_2026-10-02.kicad_pro`，主原理图及PCB同名。使用KiCad 10打开，功能子页为01_power_input至09_control_io。项目本地符号/封装库、3D模型、fp-lib-table和sym-lib-table均需保留。

普通说明用中文和默认字体，电气网络名/位号/型号/层级引脚保持ASCII，公共地为GND，维护约定见本目录AGENTS.md。编辑原理图时局部修改，保留PCB布局、走线和铜区几何，不重新运行历史整套生成脚本。

review中保留接口线序、BOM和仍有用的器件/模型资料；历史改造脚本、备份和布局试验已列入根目录清理清单。nextpcb包含已有制造导出，是否适合新投板须依据当前PCB重新核验。此目录KiCad维护工程与同级原始EasyEDA工程独立，不能把一个格式的旧导出当作另一个的同步结果。

FPGA固件及其布局布线结果见根目录HANDOFF-20261030.md；当前PCB源文件和器件库的内容保留。

Notes on the sheet:
独立降压、跳帽选择与传感器滤波
默认短接JP1的1-2：板载3.3V。只安装一个跳帽；电机故障恢复后须重新发解锁脉冲。
右侧AT8236、编码器与电流监测
板载总保险、防反接与电压窗口
动力总开关与回生泄放
急停、上电复位与解锁锁存
实线为实际层级网络连接；远距离控制、监测信号采用同名标签。
输出过压与动力过流检测
左侧AT8236、编码器与电流监测
逻辑板控制与电源监测接口
两路降压与六针供电口
电池经XT60接入板载MINI总保险；单体电芯保护仍须落实。PCB封装与网络已同步，布局布线待完成。
电源板功能连接总图：两路5V、独立3.3V与双电机驱动

Parts:
C131: 470uF/25V; CP_Radial_D10.0mm_P5.00mm
C132, C133, C138: 100nF/50V; C_0805_2012Metric
C134, C135: 1uF/25V; C_0603_1608Metric
C136, C137: 1nF/C0G; C_0603_1608Metric
J4: MG513电机 / 核对线序; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
R94: 0.020R/1%/1W; R_2512_6332Metric
R95, R96: 1k; R_0603_1608Metric
R97: 100k; R_0603_1608Metric
R98, R99, R101, R103: 10k; R_0603_1608Metric
R100, R102: 100R; R_0603_1608Metric
RV2: 10k/3296W; Potentiometer_Bourns_3296W_Vertical; MPN 3296W-1-103LF
U4: AT8236双路模块; AT8236_Dual_PinSocket_2x7_P2.54_Row23.1275mm; MPN AT8236 dual module / vendor-specific
U11: 74HC08D; SOIC-14_3.9x8.7mm_P1.27mm; MPN SN74HC08DR
U26: INA180A1IDBVR; SOT-23-5; MPN INA180A1IDBVR

Connections:
+3V3: C133.1, C138.1, J4.2, R101.1, R103.1, U26.5 (V+); also elsewhere on the board
+3V3_SENS: RV2.1; also elsewhere on the board
ENC_R_A: J4.3, R100.1
ENC_R_A_FPGA: C136.1, R100.2, R101.2; also elsewhere on the board
ENC_R_B: J4.4, R102.1
ENC_R_B_FPGA: C137.1, R102.2, R103.2; also elsewhere on the board
GND: C131.2, C132.2, C133.2, C134.2, C135.2, C136.2, C137.2, C138.2, J4.5, R97.2, R98.2, R99.2, RV2.3, U4.3 (BIN1), U4.4 (BIN2), U4.7 (GND), U4.8 (GND), U26.2 (GND); also elsewhere on the board
MOTOR_ARMED: U11.10, U11.13; also elsewhere on the board
unnamed: J4.1, U4.1 (AOUT2)
unnamed: J4.6, U4.2 (AOUT1)
unnamed: R95.1, U26.1
unnamed: R96.1, RV2.2
unnamed: R98.1, U4.12 (AIN1), U11.8
unnamed: R99.1, U4.11 (AIN2), U11.11
R_PWM_FWD_RAW: U11.9; also elsewhere on the board
R_PWM_REV_RAW: U11.12; also elsewhere on the board
VM_R: C131.1, C132.1, R94.2, U4.6 (VM), U4.9 (VM), U26.4 (-); also elsewhere on the board
VM_R_IMON: C134.1, R95.2; also elsewhere on the board
VM_SWITCHED: R94.1, U26.3 (+); also elsewhere on the board
VREF_R: C135.1, R96.2, R97.1, U4.5 (VCC_REF), U4.10 (VCC_REF)

Notes on the sheet:
排间距23.1275毫米，沿用原电路板；对排引脚编号已纠正。 限流电流=参考电压/(10×采样电阻)；安装电机前先测阻值并校准。 10正转、01反转、00滑行、11制动；B通道未用。编码器线序须与实物一致。
增益20，采样电阻20mΩ：约0.4V/A 输出滤波约1ms；母线过流阈值约3.04A 母线电流不同于绕组电流；滤波关断不能替代入口保护 入口总保险板载；模块内部限流须校准
右电机驱动：使用A通道 / 可调限流参考 / 双排排母
右电机：电子过流关断、电流监测与本地储能

Parts:
C122: 470uF/25V; CP_Radial_D10.0mm_P5.00mm
C123, C124, C127, C130: 100nF/50V; C_0805_2012Metric
C125, C126: 1uF/25V; C_0603_1608Metric
C128, C129: 1nF/C0G; C_0603_1608Metric
J3: MG513电机 / 核对线序; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
R84: 0.020R/1%/1W; R_2512_6332Metric
R85, R86: 1k; R_0603_1608Metric
R87: 100k; R_0603_1608Metric
R88, R89, R91, R93: 10k; R_0603_1608Metric
R90, R92: 100R; R_0603_1608Metric
RV1: 10k/3296W; Potentiometer_Bourns_3296W_Vertical; MPN 3296W-1-103LF
U2: AT8236双路模块; AT8236_Dual_PinSocket_2x7_P2.54_Row23.0005mm; MPN AT8236 dual module / vendor-specific
U11: 74HC08D; SOIC-14_3.9x8.7mm_P1.27mm; MPN SN74HC08DR
U25: INA180A1IDBVR; SOT-23-5; MPN INA180A1IDBVR

Connections:
+3V3: C124.1, C127.1, C130.1, J3.2, R91.1, R93.1, U11.14 (VCC), U25.5 (V+); also elsewhere on the board
+3V3_SENS: RV1.1; also elsewhere on the board
ENC_L_A: J3.3, R90.1
ENC_L_A_FPGA: C128.1, R90.2, R91.2; also elsewhere on the board
ENC_L_B: J3.4, R92.1
ENC_L_B_FPGA: C129.1, R92.2, R93.2; also elsewhere on the board
GND: C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, J3.5, R87.2, R88.2, R89.2, RV1.3, U2.3 (BIN1), U2.4 (BIN2), U2.7 (GND), U2.8 (GND), U11.7 (GND), U25.2 (GND); also elsewhere on the board
L_PWM_FWD_RAW: U11.1; also elsewhere on the board
L_PWM_REV_RAW: U11.4; also elsewhere on the board
MOTOR_ARMED: U11.2, U11.5; also elsewhere on the board
unnamed: J3.1, U2.1 (AOUT2)
unnamed: J3.6, U2.2 (AOUT1)
unnamed: R85.1, U25.1
unnamed: R86.1, RV1.2
unnamed: R88.1, U2.12 (AIN1), U11.3
unnamed: R89.1, U2.11 (AIN2), U11.6
VM_L: C122.1, C123.1, R84.2, U2.6 (VM), U2.9 (VM), U25.4 (-); also elsewhere on the board
VM_L_IMON: C125.1, R85.2; also elsewhere on the board
VM_SWITCHED: R84.1, U25.3 (+); also elsewhere on the board
VREF_L: C126.1, R86.2, R87.1, U2.5 (VCC_REF), U2.10 (VCC_REF)

Notes on the sheet:
增益20，采样电阻20mΩ：约0.4V/A 输出滤波约1ms；母线过流阈值约3.04A 母线电流不同于绕组电流；滤波关断不能替代入口保护 入口总保险板载；模块内部限流须校准
左电机驱动：使用A通道 / 可调限流参考 / 双排排母
排间距23.0005毫米，沿用原电路板；对排引脚编号已纠正。 限流电流=参考电压/(10×采样电阻)；安装电机前先测阻值并校准。 10正转、01反转、00滑行、11制动；B通道未用。编码器线序须与实物一致。
左电机：电子过流关断、电流监测与本地储能
