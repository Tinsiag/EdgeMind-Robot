# Repository Tinsiag/EdgeMind-Robot (continued)

## KiCad design pcb/power/kicad/ProPrj_power_2026-10-02.kicad_pcb (continued)

Parts:
C58: 470uF/35V; CP_Radial_D10.0mm_P5.00mm
C59: 10uF/50V; C_0805_2012Metric
C60, C102, C103: 100nF/50V; C_0805_2012Metric
C101: 100uF/25V; CP_Radial_D10.0mm_P5.00mm
CN1: XT60PW-M / 三串电池; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
D1: SMBJ15CA; D_SMB; MPN SMBJ15CA
D2, D3: BZT52C12; D_SOD-123
F1: 10A/32V MINI总保险; Fuseholder_Blade_Mini_Keystone_3568; MPN 0297010.J
Q1, Q3: IRF4905; TO-220-3_Vertical; MPN IRF4905
Q4: MMBT3904; SOT-23; MPN MMBT3904
R51: 100k; R_0603_1608Metric
R52: 2.2k; R_0603_1608Metric
R53, R59, R64: 10k; R_0603_1608Metric
R54: 4.7k; R_0603_1608Metric
R55: 26.1k/0.1%; R_0603_1608Metric
R56, R58, R61, R63: 10.0k/0.1%; R_0603_1608Metric
R57, R62: 46.4k/0.1%; R_0603_1608Metric
R60: 28.7k/0.1%; R_0603_1608Metric
U21: TL431BIDBZR; SOT-23; MPN TL431BIDBZR
U22, U23: LM393BIDR; SOIC-8_3.9x4.9mm_P1.27mm; MPN LM393BIDR

Connections:
+3V3: R64.1; also elsewhere on the board
BAT_POS: CN1.2, F1.1
BUCK_ENABLE: R54.1, R59.2, U22.1, U22.7; also elsewhere on the board
GND: C58.2, C59.2, C60.2, C101.2, C102.2, C103.2, CN1.1, D1.2 (A2), Q4.2 (E), R51.2, R56.2, R58.2, R61.2, R63.2, U21.3 (A), U22.4 (V-), U23.4 (V-); also elsewhere on the board
MOTOR_POWER_OK: R64.2, U23.1, U23.7; also elsewhere on the board
unnamed: D2.2 (A), Q1.1 (G), R51.1
unnamed: D3.2 (A), Q3.1 (G), Q4.3 (C), R53.2
unnamed: F1.2, Q1.2 (D)
unnamed: Q4.1 (B), R54.2
unnamed: R55.2, R56.1, U22.3 (+)
unnamed: R57.2, R58.1, U22.6 (-)
unnamed: R60.2, R61.1, U23.3 (+)
unnamed: R62.2, R63.1, U23.6 (-)
VBAT_SYS: C58.1, C59.1, C60.1, C102.1, C103.1, D1.1 (A1), D2.1 (K), D3.1 (K), Q1.3 (S), Q3.3 (S), R52.1, R53.1, R55.1, R57.1, R59.1, R60.1, R62.1, U22.8 (V+), U23.8 (V+); also elsewhere on the board
VLOGIC_IN: C101.1, Q3.2 (D); also elsewhere on the board
VREF_2V495: R52.2, U21.1 (K), U21.2 (REF), U22.2 (-), U22.5 (+), U23.2 (-), U23.5 (+); also elsewhere on the board

Notes on the sheet:
电池母线基准与降压输入开关
欠压与过压窗口：逻辑约9.0-14.1V；动力约9.65-14.1V
输入：三串11.1V锂聚合物电池 / 板载总保险与防反接
开集电极故障输出共同拉低使能。电机故障清除解锁锁存；电压恢复后不自动解锁。 总电压监测不能替代单体电芯保护。阈值、响应和过冲须实测。
电池：11.1V / 3600mAh / 35C；满电12.6V。 F1板载：XT60正极之后、防反接管之前。 保险片：集电通0297010.J，10A/32V，初值待实测。 保险座：四孔9.92×3.40mm；与保险片分别采购。 照片不能确认电池保护板；单体电芯保护仍须落实。 瞬态抑制二极管不能把电压固定在17V以下。

Schematic: 09_control_io.kicad_sch, 逻辑板控制与电源监测接口

Parts:
C143: 100nF/25V; C_0603_1608Metric
J1: 左轮控制; PinHeader_1x08_P2.54mm_Vertical
J2: 右轮控制; PinHeader_1x08_P2.54mm_Vertical
J18: 电源监测 / 外部模数转换; PinHeader_1x12_P2.54mm_Vertical
R124: 100k/0.1%; R_0603_1608Metric
R125: 27.4k/0.1%; R_0603_1608Metric

Connections:
3V3_FPGA_IN: J1.6, J2.3; also elsewhere on the board
+3V3: J18.1; also elsewhere on the board
BAT_ADC: C143.1, J18.3, R124.2, R125.1
BAT_WARN_N: J18.4; also elsewhere on the board
ENC_L_A_FPGA: J1.7; also elsewhere on the board
ENC_L_B_FPGA: J1.8; also elsewhere on the board
ENC_R_A_FPGA: J2.2; also elsewhere on the board
ENC_R_B_FPGA: J2.1; also elsewhere on the board
ESTOP_OK: J18.11; also elsewhere on the board
EXT_KILL_N: J2.7; also elsewhere on the board
GND: C143.2, J1.5, J2.4, J18.2, R125.2; also elsewhere on the board
L_PWM_FWD_RAW: J1.1; also elsewhere on the board
L_PWM_REV_RAW: J1.2; also elsewhere on the board
MOTOR_ARM: J1.3; also elsewhere on the board
MOTOR_ARMED: J2.8, J18.8; also elsewhere on the board
MOTOR_PERMIT: J1.4; also elsewhere on the board
MOTOR_POWER_OK: J18.7; also elsewhere on the board
POR_OK: J18.12; also elsewhere on the board
R_PWM_FWD_RAW: J2.5; also elsewhere on the board
R_PWM_REV_RAW: J2.6; also elsewhere on the board
USB1_FAULT_PULSE_N: J18.9; also elsewhere on the board
USB2_FAULT_PULSE_N: J18.10; also elsewhere on the board
VBAT_SYS: R124.1; also elsewhere on the board
VM_L_IMON: J18.5; also elsewhere on the board
VM_R_IMON: J18.6; also elsewhere on the board

Notes on the sheet:
电池采样：12.6V对应约2.71V，需要外部模数转换器。 J1第6脚与J2第3脚均为逻辑板3.3V输入， 默认与本板输出隔离，只接同一个电源域。 复位或看门狗超时时，运行许可必须为低。 安全检查后，以解锁脉冲的上升沿解锁。 外部故障脚接受开漏低电平。 荔枝派普通输入输出需要合适的电平转换。
控制接口 / 电源方向 / 互斥电源选择
PCB封装与网络已同步，布局布线待完成。 仍须核对模块采样电阻、编码器版本与逻辑板供电接口。

Schematic: 03_aux_3v3.kicad_sch, 独立3.3V与电源选择

Parts:
C108: 10uF/25V; C_0805_2012Metric
C109: 100nF/50V; C_0603_1608Metric
C110, C111: 22uF/10V; C_0805_2012Metric
C112: 10uF/10V; C_0805_2012Metric
C113, C114, C115, C116, C117: 100nF/50V; C_0805_2012Metric
FB1: 220Ω@100MHz / 1A; L_0805_2012Metric
J9: 可选逻辑板3.3V输入; PinHeader_1x02_P2.54mm_Vertical
J10: 惯性传感器电源; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J11: 测距传感器1电源; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J12: 测距传感器2电源; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J13: 测距传感器3电源; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J14: 3.3V辅助输出; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
JP1: 1-2板载 / 2-3逻辑板; PinHeader_1x03_P2.54mm_Vertical
L3: 4.7uH; L_Changjiang_FXL0630; MPN FXL0630-4R7-M
U3: AP63203WU-7; TSOT-23-6; MPN AP63203WU-7

Connections:
3V3_FPGA_IN: J9.1, JP1.3; also elsewhere on the board
+3V3: FB1.1, J14.1, JP1.2; also elsewhere on the board
+3V3_ONBOARD: JP1.1; also elsewhere on the board
+3V3_RAW: C110.1, C111.1, L3.2, U3.1 (FB); also elsewhere on the board
+3V3_SENS: C112.1, C113.1, C114.1, C115.1, C116.1, C117.1, FB1.2, J10.1, J11.1, J12.1, J13.1; also elsewhere on the board
BUCK_ENABLE: U3.2 (EN); also elsewhere on the board
GND: C108.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, J9.2, J10.2, J11.2, J12.2, J13.2, J14.2, U3.4 (GND); also elsewhere on the board
unnamed: C109.2, U3.6 (BST)
unnamed: C109.1, L3.1, U3.5 (SW)
VLOGIC_IN: C108.1, U3.3 (IN); also elsewhere on the board

Notes on the sheet:
默认独立3.3V降压 / 初始负载预算0.5A
传感器电源滤波 / 仅接已确认支持3.3V的成品模块
芯片标称2A能力不能代替接口与散热验收。 反馈取自保护开关前的稳压输出。 4.7µH位于手册允许的2.2-10µH范围内。
默认短接1-2：板载3.3V供电。 确认逻辑板电流余量后，才能改为2-3。 只能装一个跳帽，不能并联两个电源。 默认安装板载降压电路。
本板3.3V供给编码器、电流监测和安全逻辑；传感器信号接逻辑板。 裸芯片与成品模块的供电要求可能不同，须核对实际模块。
JP1电源选择：只安装一个跳帽

Board: 2 copper layers, 96.0 x 97.0 mm, 211 parts (0 on the bottom side), 111 nets.

## KiCad design pcb/power/power.kicad_pcb

Board: 2 copper layers, 53 parts (0 on the bottom side), 18 nets, no tracks yet.

Parts:
C1, C92, C102: 100 nF 25 V; C_0603_1608Metric
C2, C4: 470 uF 25 V; CP_Radial_D10.0mm_P5.00mm
C3: 10 nF; C_0603_1608Metric
C10, C11, C30, C31: 10u/50V; C_1210_3225Metric
C12, C13, C14: 47u/10V; C_1210_3225Metric
C32, C33, C34: 47u/25V; C_1210_3225Metric
C50: 4.7 uF 10V; C_0805_2012Metric
C51, C52: 22 uF 10V; C_0805_2012Metric
C80: 150 uF 10V; CP_Radial_D8.0mm_P3.50mm
C81: 100 nF 10V; C_0603_1608Metric
C82: 10 uF 10V; C_0805_2012Metric
C90, C100: 22 nF 25 V; C_0603_1608Metric
C91, C101: 100 nF 16 V; C_0603_1608Metric
C93, C103: 47 uF 25 V; C_1210_3225Metric
D1: SMBJ15A; D_SMB
D2: SMBJ15A 待核; D_SMB
J1: XT60 母座; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J3: USB-C 5V 输出; USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal
R1: 180 k 1%; R_0603_1608Metric
R2: 47 k 1%; R_0603_1608Metric
R11: 40.2 k 1%; R_0603_1608Metric
R12, R32, R83, R93: 10 k 1%; R_0603_1608Metric
R13: 13 k; R_0603_1608Metric
R24, R51: 100 k 1%; R_0603_1608Metric
R31: 80.6 k 1%; R_0603_1608Metric
R33: 6.34 k; R_0603_1608Metric
R50: 453 k 1%; R_0603_1608Metric
R80, R90: 13 k 1%; R_0603_1608Metric
R81, R91: 20 k 1%; R_0603_1608Metric
R82, R92: 1.8 k 1%; R_0603_1608Metric
U1: LM74700QDBVRQ1; SOT-23-6
U4: TLV62569DBVR; SOT-23-5

Connections:
/3V3: C51.1, C52.1, R50.1, R80.1, R83.1, R90.1, R93.1
/5V_MAIN: C12.1, C13.1, C14.1, C50.1, R11.1, U4.1 (EN), U4.4 (VIN)
/5V_USB: C82.1, J3.A9 (VBUS), J3.B9 (VBUS)
/9V_FPGA: C32.1, C33.1, C34.1, R31.1
/GND: C2.2, C3.2, C4.2, C10.2, C11.2, C12.2, C13.2, C14.2, C30.2, C31.2, C32.2, C33.2, C34.2, C50.2, C51.2, C52.2, C80.2, C81.2, C82.2, C92.2, C93.2, C102.2, C103.2, D1.2 (A), D2.2 (A), J1.1 (-), J3.A12 (GND), J3.B12 (GND), J3.SH (SHIELD), R2.2, R12.2, R13.2, R32.2, R33.2, R51.2, R81.2, R82.2, R91.2, R92.2, U1.2 (GND), U4.2 (GND)
/MOTOR_ON: C4.1, D2.1 (K)
/VBAT_PROT: C2.1, C10.1, C11.1, C30.1, C31.1, D1.1 (K), R1.1, U1.4 (CATHODE)
unnamed: C3.1, R1.2, R2.1
unnamed: C1.2, U1.3 (EN), U1.6 (ANODE)
unnamed: C1.1, U1.1 (VCAP)
unnamed: R11.2, R12.1
unnamed: R31.2, R32.1
unnamed: R50.2, R51.1, U4.5 (FB)
unnamed: C80.1, C81.1
unnamed: C91.1, C92.1, C93.1
unnamed: R80.2, R81.1
unnamed: C101.1, C102.1, C103.1
unnamed: R90.2, R91.1

## KiCad design model/hardware/ACX720-V3机械文件/converted/acx720_v2.kicad_pcb

File model/README.md:

# 当前机械设计

主要入口为 [V5 屏幕/传感器装配](chassis/v5-rgb-touch-display/README.md)，包括完整FreeCAD装配、STEP、第三层板STL与孔位图、离线查看器及重建/验证脚本。

`hardware/` 保留板卡、电机和电源板原始机械资料。`chassis/v4-lidar-imu/` 中的基础装配、网格缓存、参数、核验数据和STEP仍是V5重建及导航几何来源；这些必要输入不是待删除备份。导航包络的准确来源SHA见A745的config/geometry.json，原几何没有在本次清理准备中修改。

历史版本的保留/删除情况见[维护记录](../docs/maintenance.md)。本轮历史缓存目录删除被自动审批拒绝，不能将计划写成已完成。当前V5及上述五个基础输入必须保留。

装配中的屏幕安装孔位、接口和部分板卡高度仍包含试摆参考，制作依据以V5说明与实际测量为准。厂商原始模型及Three.js许可保持原样。

Board: 2 copper layers, 149.9 x 109.2 mm, 33 parts (0 on the bottom side), 5 nets, no tracks yet.

Parts:
BT1: CR1220
D34: SIP3
H1, H2, H3, H4: HOLE5R715MM3R175MM-8STAR
J2, J5: USB-MICRO
J3: RJ45_HR911130C
J4: JACK_PWR
J6, J7: HDMI_A
LS1: BEEP09X05
P1: IDC3-14
P2: HDR1X3
P3: IDC-40J
P4: HD20-100-R
P5: HDR2X18
P6: HDR2X4
S0, S1, S2, S3, S4: SW-PB_3_6_4_3
S5: SS12D06_1P2T_
SW0, SW1, SW2, SW3, SW4, SW5, SW6, SW7: SW-1X2

Connections:
EX_VCC: J4.2, S5.3
GND: D34.2, H1.1, H2.1, H3.1, H4.1, J2.4, J2.5, J2.6, J2.7, J2.8, J2.9, J3.10, J3.12, J3.15, J3.16, J4.1, J4.3, J5.4, J5.5, J5.6, J5.7, J5.8, J5.9, J6.2, J6.5, J6.8, J6.11, J6.17, J6.20, J6.21, J6.22, J6.23, J7.2, J7.5, J7.8, J7.11, J7.17, J7.20, J7.21, J7.22, J7.23, P1.1, P1.3, P1.5, P1.7, P1.9, P1.11, P1.13, P3.12, P3.30, P4.2, P5.2, P5.24, P5.28, P5.29, S0.1, S1.1, S2.1, S3.1, S4.1, SW0.1, SW0.5, SW1.1, SW1.5, SW2.1, SW2.5, SW3.1, SW3.5, SW4.1, SW4.5, SW5.1, SW5.5, SW6.1, SW6.5, SW7.1, SW7.5
NETP6/1: P6.1, P6.3, P6.5
VCC3V3: J3.14, LS1.1, P1.2, P3.29, P5.1, P5.26, P5.27, P6.7
VCC5V0: D34.3, P3.11, P5.30, S5.2
